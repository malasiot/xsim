Commit message: kuka iiwa solver

File: data/robots/dual_arm_kuka_iiwa/iiwa.urdf (robot description, URDF)
Before this commit: robot None, 10 links, 9 joints
Joints:
- joint joint_a7-tool0: origin xyz=0 0 0.154 rpy=0 0 0 -> xyz=0 0 0.126 rpy=0 0 0
