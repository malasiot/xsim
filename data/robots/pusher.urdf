Commit message: pusher world

File: data/robots/pusher.urdf (robot description, URDF)
Before this commit: robot pusher, 3 links, 1 joints
Joints:
- joint pusher_slider_joint: axis 0 1 0 -> 1 0 0
